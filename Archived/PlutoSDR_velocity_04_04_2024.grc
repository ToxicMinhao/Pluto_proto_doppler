options:
  parameters:
    generate_options: qt_gui
    id: pluto_5G5_test
    output_language: python
    title: Pluto 5.5 GHz Test
  states: {}

blocks:
- name: deci
  id: variable
  parameters:
    value: '50'
  states: {}
- name: doppler_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: '500'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 1
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: deci
    gain: '1'
    high_cutoff_freq: '700'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '250'
    win: window.WIN_HAMMING
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: tone_freq+5
    low_cutoff_freq: tone_freq-5
    samp_rate: samp_rate/50
    type: fir_filter_ccf
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: doppler_gain
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8192'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '8192'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class doppler_velocity_calc(gr.sync_block):
          """
          A custom GNU Radio block to calculate velocity from a simulated frequency shift.

          Attributes:
              transmitted_freq (float): The frequency of the transmitted signal in Hz.
              speed_of_light (float): The speed of light in meters per second, typically 3e8.
          """
          def __init__(self, transmitted_freq=500, speed_of_light=3e8, samp_rate=40000, fft_size = 8192, carrier_freq=3.5e9):
              gr.sync_block.__init__(self, name="doppler_velocity_calc", in_sig=[np.float32], out_sig=[np.float32])
              self.transmitted_freq = transmitted_freq
              self.speed_of_light = speed_of_light
              self.samp_rate = samp_rate
              self.fft_size = fft_size
              self.carrier_freq = carrier_freq

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              part_of_in0 = in0[4050:8192]
              input_max = np.argmax(part_of_in0)
              frequency_bin_width = self.samp_rate / self.fft_size
              if np.max(part_of_in0) < 50:
                  out[:] = 0
                  #print("start frame")
                  #print('index of max:', input_max)
                  #print('value of max:', part_of_in0[input_max])
                  #print('bin width:', frequency_bin_width)
                  #print('length of input stream:', len(in0))
                  #print('velocity:', out)
                  #print("end frame")
              else: 
                  delta_f = (input_max - (4198-4050)) * frequency_bin_width
                  velocity = (delta_f * self.speed_of_light) / (2*self.carrier_freq)
                  out[:] = velocity
                  #print("start frame")
                  #print('index of max:', input_max)
                  #print('value of max:', part_of_in0[input_max])
                  #print('bin width:', frequency_bin_width)
                  #print('length of input stream:', len(in0))
                  #print('velocity:', out)
                  #print("end frame")

              return len(output_items[0])
    carrier_freq: '3500000000'
    fft_size: '8192'
    samp_rate: '40000'
    speed_of_light: '300000000.0'
    transmitted_freq: '500'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class average_speed(gr.sync_block): 
          def __init__(self, target_points = 262144):  
              gr.sync_block.__init__(self, name='average_speed', in_sig=[np.float32], out_sig=[np.float32])
              self.target_points = target_points


          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              accumulated_points = np.array([])
              while accumulated_points.size < self.target_points:
                  accumulated_points = np.concatenate((accumulated_points, in0))
              accumulated_points = accumulated_points[:self.target_points]
              sum_of_points = np.sum(accumulated_points)
              average = sum_of_points / self.target_points
              accumulated_points = np.array([])
              out[:] = average
              return len(output_items[0])
    target_points: '262144'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '8192'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(8192)
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '40000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    bandwidth: '20000000'
    center_freq: 3.5e9
    gain: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: 3.5e9
    gain: '64'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', soapy_plutosdr_sink_0, '0']
- [band_pass_filter_0, '0', band_reject_filter_0, '0']
- [band_reject_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_1, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_1, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_number_sink_1, '0']
- [epy_block_1, '0', qtgui_number_sink_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [soapy_plutosdr_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
